## blinky/sdkconfig.defaults
```kconfig
CONFIG_PARTITION_TABLE_CUSTOM=y
CONFIG_PARTITION_TABLE_CUSTOM_FILENAME="partitions.txt"
CONFIG_BOOTLOADER_APP_ROLLBACK_ENABLE=y
```
